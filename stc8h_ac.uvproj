# Keil uVision project stc8h_ac.uvproj, settings and files
target stc8h_ac (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: stc8h_ac +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\LIB;.\DRIVER;.\STC8H_LIB
  group APP
    ./: STARTUP.A51
    ./APP/: main.c AppFunctionSetup.c TimerISR.c
  group LIB
    ./LIB/: UART.c Timer.c GPIO.c I2C.c
  group STC8H_LIB
    ./STC8H_LIB/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_UART.c
  group DRIVER
    ./DRIVER/: TouchKey.c LCD_Seg.c
